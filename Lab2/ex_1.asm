;ex_1
		ORG	8000H
LOOP:	MOV	DPTR,#0E060H
		MOV	A,#3FH
		MOVX	@DPTR,A
		MOV	A,#5BH
		MOVX	@DPTR,A
		MOV	A,#66H
		MOVX	@DPTR,A
		MOV	A,#7DH
		MOVX	@DPTR,A
		MOV	A,#7FH
		MOVX	@DPTR,A
		MOV	A,#77H
		MOVX	@DPTR,A
		MOV	A,#39H
		MOVX	@DPTR,A
		MOV	A,#79H
	
		JMP	LOOP
	
DELAY_500M:	CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		
		RET
DELAY100MS:	MOV	R6,#200
DLY100MS:	CALL	DELAY500U
		DJNZ	R6,DLY100MS
		RET
DELAY500U:	MOV	R5,#230
		DJNZ	R5,$
		RET
		END