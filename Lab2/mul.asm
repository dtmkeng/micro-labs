	;mul	
	ORG	0000H
	MOV	DPTR,#8500H
	MOVX	A,@DPTR
	MOV	B,A
	MUL	AB
	INC	DPTR	
	MOVX	@DPTR,A	
	MOV	R0,#40H
	MOV	@R0,A
	MOV	A,@R0
	MOV	B,#46H
	DIV	AB
	MOV	R1,A
	MOV	A,B
	MOV	B,#0AH
	DIV	AB
	MOV 	R2,A
	MOV	R3,B
	INC 	DPTR
	MOV	A,R3	
	MOVX	@DPTR,A
	INC	DPTR
	MOV	A,R2
	MOVX	@DPTR,A
	
	END