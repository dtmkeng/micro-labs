;Test2.Asm B5917273
	ORG	8000H
LOOP:	MOV	DPTR,#0E060H
	MOV 	A,#7CH
	MOVX	@DPTR,A
	CALL DELAY_500M
	MOV	A,#6DH
	MOVX	@DPTR,A
	CALL DELAY_500M
	MOV 	A,#6FH
	MOVX	@DPTR,A
	CALL DELAY_500M
	MOV	A,#06H
	MOVX	@DPTR,A
	CALL DELAY_500M
	MOV 	A,#07H
	MOVX	@DPTR,A
	CALL DELAY_500M
	MOV	A,#5BH
	MOVX	@DPTR,A
	CALL DELAY_500M
	MOV	A,#07H
	MOVX	@DPTR,A
	CALL DELAY_500M
	MOV	A,#47H
	MOVX	@DPTR,A
	CALL DELAY_500M
	JMP	LOOP
	
DELAY_2SEC:	CALL	DELAY_1SEC
		CALL	DELAY_1SEC
		RET
		
DELAY_1SEC:	CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		RET
		
DELAY_500M:	CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		RET
		
DELAY100MS:	MOV	R6,#200
DLY100MS:	CALL	DELAY500U
		DJNZ	R6,DLY100MS
		RET
DELAY500U:	MOV	R5,#230
		DJNZ	R5,$
		RET
		
		END