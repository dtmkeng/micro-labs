;Test3.Asm
		ORG	8000H
LOOP:		MOV	R0,#01H
		MOV	R1,#0FFH
		CALL	DISP_OUT
		CALL	DELAY_500M
	
		MOV	R0,#01H
		MOV	R1,#0FFH
		CALL	DISP_OUT
		CALL	DELAY_500M
		JMP	LOOP
	
;***************************************
;* Display Digital_R0 by Value_R1
;***************************************
DISP_OUT: 	MOV	DPTR,#0E002H
		MOV	A,R0
		MOVX	@DPTR,A
		MOV	DPTR,#0E001H
		MOV	R1,A
		MOVX	@DPTR,A
		CLR	A
		DJNZ	Acc,$
		RET
;***************************************
;* Delay Subroutine
;***************************************
DELAY_2SEC:	CALL	DELAY_1SEC
		CALL	DELAY_1SEC
		RET
		
DELAY_1SEC:	CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		RET
		
DELAY_500M:	CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		CALL	DELAY100MS
		RET
		
DELAY100MS:	MOV	R6,#200
DLY100MS:	CALL	DELAY500U
		DJNZ	R6,DLY100MS
		RET
DELAY500U:	MOV	R5,#230
		DJNZ	R5,$
		RET
		
		END