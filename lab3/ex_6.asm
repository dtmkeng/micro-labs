;ex_6
	ORG	0000H
	MOV	DPTR,#1000H
	MOV	R4,DPH
	MOV	R5,DPL
	MOV	DPTR,#2300H
	MOV	R6,DPH
	MOV	R7,DPL
	
	MOV	R3,#2
LOOP:	MOV	R2,#143
NEXT:	MOV	DPH,R4
	MOV	DPL,R5
	MOVX	A,@DPTR
	INC	DPTR
	MOV	R4,DPH
	MOV	R5,DPL
	MOV	DPH,R6
	MOV	DPL,R7
	MOVX	@DPTR,A
	INC	DPTR
	MOV	R6,DPH
	MOV	R7,DPL
	DJNZ	R2,NEXT
	DJNZ	R3,LOOP	
	
	MOV	DPH,R4
	MOV	DPL,R5
	MOVX	A,@DPTR
	INC	DPTR
	MOV	R4,DPH
	MOV	R5,DPL
	MOV	DPH,R6
	MOV	DPL,R7
	MOVX	@DPTR,A
	INC	DPTR
	MOV	R6,DPH
	MOV	R7,DPL
	
	JMP	$
	END